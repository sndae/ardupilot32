# Keil uVision project Project.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\project;..\..\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: stm32f10x_it.c main.c SysClock.c VN100.c VN_user.c VN_lib.c VN_math.c
  group FWLib
    ../../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Doc
    ./: readme.txt
