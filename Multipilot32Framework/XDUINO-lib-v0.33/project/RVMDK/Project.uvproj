# Keil uVision project Project.uvproj, settings and files
target ET-STM32F103 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../: stm32f10x_it.c main.cpp
  group FWLib
    ../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Doc
    ../: Readme.txt COPYING.txt COPYING.LESSER.txt
  group XduinoLib
    ../: Xduino.cpp defineName.cpp doDAC.cpp doGPIO.cpp doTime.cpp doADC.cpp doEXTI.cpp compatArduino.cpp doSerial.cpp xduinoInit.cpp
  group AP32Lib
    ../../ap32lib/: AP_ADC.cpp AP_ADC.h AP_ADC_ADS7844.cpp AP_ADC_ADS7844.h AP_ADC_HIL.cpp AP_ADC_HIL.h
    ../../APM_BMP085/: APM_BMP085.cpp APM_BMP085.h
    ../../Wire/: Wire.cpp Wire.h
    ../../SPI/: SPI.cpp SPI.h
    ../../APM_RC/: APM_RC.h APM_RC.cpp
